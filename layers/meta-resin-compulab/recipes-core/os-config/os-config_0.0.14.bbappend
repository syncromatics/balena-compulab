SRC_URI = "git://github.com/balena-os/os-config.git;protocol=git"
